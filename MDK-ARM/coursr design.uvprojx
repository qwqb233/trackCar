# Keil uVision project coursr design.uvprojx, settings and files
target coursr design (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: coursr design +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Src;../Core/Src/buttonLib/Inc;../Core/Src/exit/Inc;../Core/Src/iic/Inc;../Core/Src/motorLib/Inc;../Core/Src/redLib/Inc;../Core/Src/time/Inc;../Core/Src/traLib/Inc;../Core/Src/US_ranging/Inc;../Core/Src/memoryLib/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Application/User/Core
    ../Core/Inc/: main.h
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group lib
    ../Core/Src/buttonLib/Inc/: button.h
    ../Core/Src/buttonLib/Src/: button.c
    ../Core/Src/exit/Inc/: project_exit.h
    ../Core/Src/exit/Src/: project_exit.c
    ../Core/Src/iic/Inc/: colorRe.h OLED.h OLED_font.h OLEDMenu.h
    ../Core/Src/iic/Src/: colorRe.c OLED.c OLEDMenu.c
    ../Core/Src/motorLib/Inc/: current.h motorClass.h
    ../Core/Src/motorLib/Src/: current.c motorClass.c
    ../Core/Src/redLib/Inc/: led.h rgb.h
    ../Core/Src/time/Inc/: time_lib.h
    ../Core/Src/traLib/Inc/: trailing.h
    ../Core/Src/traLib/Src/: trailing.c
    ../Core/Src/US_ranging/Inc/: US_ranging.h
    ../Core/Src/US_ranging/Src/: US_ranging.c
software components: CMSIS:CORE 4.3.0
